# Keil uVision project Timer.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: Timer +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c LCD1602.c LCD1602.h ds1302.c ds1302.h Delay.c Delay.h Key.c Key.h Timer0.c Timer0.h Alarm.c Alarm.h Temperature.c Temperature.h DS18B20.c DS18B20.h OneWire.c OneWire.h
